# Keil uVision project PCB_test.uvprojx, settings and files
target PCB_test (6190000::V6.19::ARMCLANG)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: PCB_test
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group libs
    ./: SCPI_COMMANDS.c SCPI_COMMANDS.h AD5689.c AD5689.h ADS8866.c ADS8866.h
  group code
    ./: main.c
  group drivers
    ./: relai.c relai.h SPI.c SPI.h UART.c UART.h NVIC.c NVIC.h PINs.c PINs.h TIMER.c TIMER.h clock.c clock.h dma.c dma.h temp.c temp.h
  group firmware
    ./: COMMAND_DECODE.h COMMAND_DECODE.c measure.h measure.c SEND_DATA.h SEND_DATA.c settings.h settings.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
