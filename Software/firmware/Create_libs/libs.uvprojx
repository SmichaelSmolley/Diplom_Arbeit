# Keil uVision project libs.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: libs
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group code
    ./: main.c
  group libs
    ./: ads8681_lib.h AD5689_lib.h Pin_def_lib.h SPI.h Timer_DMA.h Command_decode.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
